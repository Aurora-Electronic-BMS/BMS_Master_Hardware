# Repository Aurora-Electronic-BMS/BMS_Master_Hardware

## KiCad design BMS_Master.kicad_pcb

Parts:
C33, C34, C35, C36, C37, C38: 100n; C_0603_1608Metric
D20, D21: PESD2CAN,215; SOT-23
FB2, FB3, FB4, FB5: 60R@100MHz; L_0603_1608Metric
J10: Conn_01x02; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J11: Conn_01x04; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
R41, R42, R43, R44: 60; R_0603_1608Metric
U11, U12: ISO1042; SOIC-8_7.5x5.85mm_P1.27mm

Connections:
+3V3: FB2.1, FB4.1; also elsewhere on the board
+Ext_5V: FB3.1, FB5.1; also elsewhere on the board
+Ext_24V: J11.2; also elsewhere on the board
/CAN/CAN1_RX: U11.3 (RXD); also elsewhere on the board
/CAN/CAN1_TX: U11.2 (TXD); also elsewhere on the board
/CAN/CAN2_RX: U12.3 (RXD); also elsewhere on the board
/CAN/CAN2_TX: U12.2 (TXD); also elsewhere on the board
CAN1+: D20.1 (K), J11.3, R41.1, U11.7 (CANH)
CAN1-: D20.2 (K), J11.4, R42.2, U11.6 (CANL)
CAN2+: D21.1 (K), J10.1, R43.1, U12.7 (CANH)
CAN2-: D21.2 (K), J10.2, R44.2, U12.6 (CANL)
Ext_GND: C34.1, C35.2, C37.1, C38.2, D20.3 (A), D21.3 (A), J11.1, U11.5 (GND2), U12.5 (GND2); also elsewhere on the board
GND: C33.2, C36.2, U11.4 (GND1), U12.4 (GND1); also elsewhere on the board
unnamed: C34.2, R41.2, R42.1
unnamed: C37.2, R43.2, R44.1
unnamed: C33.1, FB2.2, U11.1 (VCC1)
unnamed: C35.1, FB3.2, U11.8 (VCC2)
unnamed: C36.1, FB4.2, U12.1 (VCC1)
unnamed: C38.1, FB5.2, U12.8 (VCC2)

Notes on the sheet:
CAN
IVT

Parts:
D4, D6, D7, D8: YELLOW; D_0603_1608Metric
D5, D9: RED; D_0603_1608Metric
D10, D11, D12, D13: GREEN; D_0603_1608Metric
D14, D15, D16, D17, D19: BLUE; D_0603_1608Metric
D18: WHITE; D_0603_1608Metric
R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38: 3k3; R_0603_1608Metric

Connections:
+3V3: R30.1; also elsewhere on the board
+5V: R31.1; also elsewhere on the board
+DCDC_5V: R32.1; also elsewhere on the board
BMS NERROR: R29.1; also elsewhere on the board
ERROR_LED: R24.1; also elsewhere on the board
GND: D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K); also elsewhere on the board
HV_ACTIVE: R26.1; also elsewhere on the board
HV_MISMATCH: R28.1; also elsewhere on the board
NEG_AIR_CTRL: R23.1; also elsewhere on the board
unnamed: D4.2 (A), R23.2
unnamed: D5.2 (A), R24.2
unnamed: D6.2 (A), R25.2
unnamed: D7.2 (A), R26.2
unnamed: D8.2 (A), R27.2
unnamed: D9.2 (A), R28.2
unnamed: D10.2 (A), R29.2
unnamed: D11.2 (A), R30.2
unnamed: D12.2 (A), R31.2
unnamed: D13.2 (A), R32.2
unnamed: D14.2 (A), R33.2
unnamed: D15.2 (A), R34.2
unnamed: D16.2 (A), R35.2
unnamed: D17.2 (A), R36.2
unnamed: D18.2 (A), R37.2
unnamed: D19.2 (A), R38.2
POS_AIR_CTRL: R25.1; also elsewhere on the board
PRE_AIR_CTRL: R27.1; also elsewhere on the board
STATUS_1: R34.1; also elsewhere on the board
STATUS_2: R36.1; also elsewhere on the board
STATUS_3: R38.1; also elsewhere on the board
STATUS_4: R33.1; also elsewhere on the board
STATUS_5: R35.1; also elsewhere on the board
STATUS_6: R37.1; also elsewhere on the board

Notes on the sheet:
LED

Parts:
C9, C12: 1u; C_0603_1608Metric
C10, C11, C16, C17, C18, C20, C21, C22, C24, C25, C26, C28, C29, C47, C50, C51: 100n; C_0603_1608Metric
C13: 4u7; C_0603_1608Metric
C14, C15, C27, C44, C45: 10u; C_0603_1608Metric
C19, C23: 1uF; C_0603_1608Metric
C46, C49: 22u; C_0603_1608Metric
C48: 22pF; C_0603_1608Metric
C52: 1uf; C_0603_1608Metric
C53: 2.2u; C_0603_1608Metric
D1: BLUE; D_0603_1608Metric
D2: 1N4148W; D_SOD-123
D3: SMF36CA; D_SOD-123F
D22: BZT52C15; D_SOD-123
D23: SS34; D_SMA
D25: SMF6.0CA; D_SOD-123
F1, F3: 1A; Fuse_0603_1608Metric
F2: 2A; Fuse_0603_1608Metric
FB1: 60R@100MHz; L_0603_1608Metric
J5: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J6: Conn_01x03; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
L1: 600R@100MHz; C_0603_1608Metric
L2: 4u7; L_Changjiang_FXL0530
Q2: 2N7002K; SOT-23
R13, R14: 5k1; R_0603_1608Metric
R15, R16: 3k3; R_0603_1608Metric
R17: 1k; R_0603_1608Metric
R18: 47; C_0603_1608Metric
R45, R53, R54, R55: 100k; R_0603_1608Metric
R50: 15k; R_0603_1608Metric
R56: 2k; R_0603_1608Metric
R63: 79k; R_0603_1608Metric
T3: EE10
U3: USBLC6-2SC6; SOT-23-6
U4: CH343P; WCH_QFN-16-1EP_3x3mm_P0.5mm_EP1.8x1.8mm
U5: TPS2116DRL; SOT-583-8
U7: LF33CDT-TR; TO-252-2
U17: PW2312; SOT-23-6
U18: JW3510; TSOT-23-5

Connections:
+3V3: C12.1, F3.1, FB1.1, L1.1, R15.1, U4.1 (VIO); also elsewhere on the board
+3V3_uC: C13.1, C16.1, C18.1, C20.1, C21.1, C24.1, C25.1, C26.1, FB1.2; also elsewhere on the board
+5V: C9.2, C10.2, C28.1, C52.1, U3.5 (VBUS), U4.3 (VDD5), U4.9 (VBUS), U5.2 (VOUT), U5.7 (VOUT), U7.1 (INPUT); also elsewhere on the board
+DCDC_5V: C27.2, C44.2, C45.2, C51.1, D23.1 (K), D25.1 (A1), R16.1, R56.2, U5.3 (VIN1), U5.5 (MODE); also elsewhere on the board
+Ext_5V: C48.2, C49.2, L2.2, R63.1; also elsewhere on the board
+Ext_24V: C14.1, C15.1, C46.2, C50.1, D3.1 (A1), D22.2 (A2), F2.2, Q2.1 (G), R45.1, R53.1, T3.3, U17.5 (IN), U18.5 (VIN); also elsewhere on the board
+USB_5V: F1.1, U5.6 (VIN2)
+VDDA: C17.1, C19.1, L1.2, R18.1; also elsewhere on the board
+VREF: C22.1, C23.1, R18.2; also elsewhere on the board
/MCU/USART3_RX: U4.4 (TXD); also elsewhere on the board
/MCU/USART3_TX: U4.5 (RXD); also elsewhere on the board
/Power/CH343_D+: U3.4 (I/O2), U4.7 (UD+)
/Power/CH343_D-: U3.6 (I/O1), U4.8 (UD-)
/Power/ST_D+: J5.A6 (D+), J5.B6 (D+), U3.3 (I/O2)
/Power/ST_D-: J5.A7 (D-), J5.B7 (D-), U3.1 (I/O1)
COMO: J6.3; also elsewhere on the board
Ext_GND: C14.2, C15.2, C46.1, C49.1, C50.2, D3.2 (A2), Q2.2 (S), R50.2, R54.2, U17.2 (GND), U18.2 (GND); also elsewhere on the board
GND: C9.1, C10.1, C11.2, C12.2, C13.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C28.2, C29.2, C44.1, C45.1, C51.2, C52.2, C53.2, D25.2 (A2), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), R13.1, R14.1, R17.2, R56.1, T3.6, T3.8, U3.2 (GND), U4.2 (GND), U4.17 (GND_EPAD), U5.1 (GND), U7.2 (GND); also elsewhere on the board
unnamed: D1.2 (A), R15.2
unnamed: D1.1 (K), U4.10 (~ACT)
unnamed: D2.2 (A), R55.2, T3.1, U18.4 (SW)
unnamed: D2.1 (K), D22.1 (A1)
unnamed: D23.2 (A), T3.5, T3.7
unnamed: F1.2, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS)
unnamed: J5.A5 (CC1), R13.2
unnamed: J5.B5 (CC2), R14.2
unnamed: F2.1, J6.1
unnamed: J6.2, Q2.3 (D)
unnamed: C11.1, U4.6 (V3_{OUT})
unnamed: R16.2, R17.1, U5.4 (PR1)
unnamed: C29.1, C53.1, F3.2, U7.3 (OUTPUT)
unnamed: C47.1, U17.1 (BS)
unnamed: R45.2, U17.4 (EN)
unnamed: C48.1, R50.1, R63.2, U17.3 (FB)
unnamed: C47.2, L2.1, U17.6 (SW)
unnamed: R53.2, R54.1, U18.1 (EN/UVLO)
unnamed: R55.1, U18.3 (RFB)

Notes on the sheet:
防反接
隔离DCDC
MCU滤波
LDO
电源切换
DCDC
Type-C

Parts:
C30, C31: 100n; C_0603_1608Metric
J7, J8, J9: Conn_01x02; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
Q1: DMN61D8LQ; SOT-23
U8: ISO7730FDWR; SOIC-16W_7.5x10.3mm_P1.27mm
U9: NSD12409-Q1; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C30.1, U8.1 (VCC1); also elsewhere on the board
+Ext_5V: C31.1, U8.10 (EN2), U8.16 (VCC2); also elsewhere on the board
/Relay/NEG_AIR: U8.13 (OUTB), U9.3 (VDD2/IN2)
/Relay/NEG_GND: J8.1, U9.6 (DRAIN2)
/Relay/POS_AIR: U8.14 (OUTA), U9.1 (VDD1/IN1)
/Relay/POS_GND: J7.1, U9.8 (DRAIN1)
/Relay/PRE_AIR: Q1.1 (G), U8.12 (OUTC)
/Relay/PRE_GND: J9.1, Q1.3 (D)
COMO: J7.2, J8.2, J9.2; also elsewhere on the board
Ext_GND: C31.2, Q1.2 (S), U8.9 (GND2), U8.15 (GND2), U9.5 (SOURCE2), U9.7 (SOURCE1); also elsewhere on the board
GND: C30.2, U8.2 (GND1), U8.8 (GND1); also elsewhere on the board
NEG_AIR_CTRL: U8.4 (INB); also elsewhere on the board
POS_AIR_CTRL: U8.3 (INA); also elsewhere on the board
PRE_AIR_CTRL: U8.5 (INC); also elsewhere on the board

Notes on the sheet:
隔离控制

Parts:
C1, C2, C3, C4: 100n; C_0603_1608Metric
C5, C6, C7, C8: 100pF; C_0603_1608Metric
J3, J4: Conn_01x02; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J20, J21: Conn_01x05; PinHeader_1x05_P1.27mm_Vertical
R1, R2, R3, R4, R5, R6: 10k; R_0603_1608Metric
R7, R8, R9, R10: 1k; R_0603_1608Metric
R11, R12: 120; R_0603_1608Metric
T1, T2: HM2103NL; HM2103NL_PUL
U1, U2: LTC6820HMS-TRPBF; MS_05-08-1669_ADI

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U1.1 (EN), U1.6 (VDDS), U1.7 (POL), U1.8 (PHA), U1.9 (VDD), U1.12 (MSTR), U2.1 (EN), U2.6 (VDDS), U2.7 (POL), U2.8 (PHA), U2.9 (VDD), U2.12 (MSTR); also elsewhere on the board
/LTC6820/SPI1_CS: J20.5, R5.1, U1.5 (*CS); also elsewhere on the board
/LTC6820/SPI1_MISO: J20.3, R1.1, U1.3 (MISO); also elsewhere on the board
/LTC6820/SPI1_MOSI: J20.2, U1.2 (MOSI); also elsewhere on the board
/LTC6820/SPI1_SCK: J20.4, R3.1, U1.4 (SCK); also elsewhere on the board
/LTC6820/SPI3_CS: J21.5, R6.1, U2.5 (*CS); also elsewhere on the board
/LTC6820/SPI3_MISO: J21.3, R2.1, U2.3 (MISO); also elsewhere on the board
/LTC6820/SPI3_MOSI: J21.2, U2.2 (MOSI); also elsewhere on the board
/LTC6820/SPI3_SCK: J21.4, R4.1, U2.4 (SCK); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J20.1, J21.1, R9.2, R10.2, U1.13 (SLOW), U1.14 (GND), U2.13 (SLOW), U2.14 (GND); also elsewhere on the board
unnamed: C5.1, T1.2
unnamed: C6.1, T2.2
unnamed: C7.1, T1.5
unnamed: C8.1, T2.5
unnamed: J3.1, T1.6
unnamed: J3.2, T1.4
unnamed: J4.1, T2.6
unnamed: J4.2, T2.4
unnamed: R7.2, U1.16 (IBIAS)
unnamed: R7.1, R9.1, U1.15 (ICMP)
unnamed: R11.2, T1.3, U1.10 (IM)
unnamed: R11.1, T1.1, U1.11 (IP)
unnamed: R8.2, U2.16 (IBIAS)
unnamed: R8.1, R10.1, U2.15 (ICMP)
unnamed: R12.2, T2.3, U2.10 (IM)
unnamed: R12.1, T2.1, U2.11 (IP)

Notes on the sheet:
LTC6820

Parts:
C39, C40: 2.2uF; C_0603_1608Metric
C41, C42: 22pF; C_0603_1608Metric
C43: 100n; C_0603_1608Metric
H1, H2, H3, H4: Mounting_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
J1, J2: SolderJumper-predefined; boot
J13: Conn_01x04; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J14: Conn_01x03; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
J16: Conn_01x04; PinHeader_1x04_P1.27mm_Vertical
J17: Conn_01x04; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
R19, R59, R61: 2k2; R_0603_1608Metric
R46: 1k; R_0603_1608Metric
R47: 0; C_0603_1608Metric
R48: 220; C_0603_1608Metric
R49: 10k; R_0603_1608Metric
R51: 470; R_0603_1608Metric
R52, R58, R60, R62: 4k7; R_0603_1608Metric
R57, R64: 100k; R_0603_1608Metric
SW1: RESET; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W6.73mm_P2.54mm_LowProfile_J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
U6, U14, U15, U16: PS7802; SMD-4_L4.5-W2.7-P1.27-LS4.9-TL
U13: STM32F407VGT6; LQFP-100_14x14mm_P0.5mm
X1: X3225 16MOB4SI; Crystal_SMD_Abracon_ABM8AIG-4Pin_3.2x2.5mm

Connections:
+3V3: J16.4, J17.4, R49.2, R51.2, R57.1, R58.2, R60.2, R62.2, R64.1; also elsewhere on the board
+3V3_uC: U13.6 (VBAT), U13.11 (VDD), U13.19 (VDD), U13.28 (VDD), U13.50 (VDD), U13.75 (VDD), U13.100 (VDD); also elsewhere on the board
+Ext_5V: R52.2; also elsewhere on the board
+VDDA: U13.22 (VDDA); also elsewhere on the board
+VREF: U13.21 (VREF+); also elsewhere on the board
/CAN/CAN1_RX: U13.70 (PA11); also elsewhere on the board
/CAN/CAN1_TX: U13.71 (PA12); also elsewhere on the board
/CAN/CAN2_RX: U13.51 (PB12); also elsewhere on the board
/CAN/CAN2_TX: U13.52 (PB13); also elsewhere on the board
/I2C/SCL1: U13.95 (PB8); also elsewhere on the board
/I2C/SDA1: U13.96 (PB9); also elsewhere on the board
/LTC6820/SPI1_CS: U13.88 (PD7); also elsewhere on the board
/LTC6820/SPI1_MISO: U13.90 (PB4); also elsewhere on the board
/LTC6820/SPI1_MOSI: U13.91 (PB5); also elsewhere on the board
/LTC6820/SPI1_SCK: U13.89 (PB3); also elsewhere on the board
/LTC6820/SPI3_CS: U13.77 (PA15); also elsewhere on the board
/LTC6820/SPI3_MISO: U13.79 (PC11); also elsewhere on the board
/LTC6820/SPI3_MOSI: U13.80 (PC12); also elsewhere on the board
/LTC6820/SPI3_SCK: U13.78 (PC10); also elsewhere on the board
/MCU/BMS_ERROR: R51.1, U6.1, U13.43 (PE12)
/MCU/BMS_ERROR_OUT: J13.4, U6.3
/MCU/BOOT0: J1.2, U13.94 (BOOT0)
/MCU/BOOT1: J2.2, U13.37 (PB2)
/MCU/CHARGE_ENABLE: U13.29 (PA4), U14.3
/MCU/CHARGE_ENABLE_IN: J13.2, R59.1
/MCU/NRST: C43.1, R46.2, R49.1, U13.14 (NRST)
/MCU/PH0: R47.2, U13.12 (PH0)
/MCU/PH1: R48.2, U13.13 (PH1)
/MCU/POWER_UP: U13.24 (PA1), U16.3
/MCU/POWER_UP_IN: J13.1, R19.1
/MCU/SDC_VOLTAGE: U13.34 (PC5), U15.3
/MCU/SDC_VOLTAGE_IN: J13.3, R61.1
/MCU/SWCLK: J16.1, J17.1, U13.76 (PA14)
/MCU/SWDIO: J16.2, J17.2, U13.72 (PA13)
/MCU/USART2_RX: J14.2, U13.26 (PA3)
/MCU/USART2_TX: J14.3, U13.25 (PA2)
/MCU/USART3_RX: U13.48 (PB11); also elsewhere on the board
/MCU/USART3_TX: U13.47 (PB10); also elsewhere on the board
BMS NERROR: U13.35 (PB0); also elsewhere on the board
ERROR_LED: U13.39 (PE8); also elsewhere on the board
Ext_GND: H1.1, U14.2, U15.2, U16.2; also elsewhere on the board
GND: C39.1, C40.1, C41.2, C42.2, C43.2, H3.1, J1.1, J2.1, J14.1, J16.3, J17.3, SW1.1 (A), U6.2, U13.10 (VSS), U13.20 (VSSA), U13.27 (VSS), U13.74 (VSS), U13.99 (VSS), X1.2, X1.4; also elsewhere on the board
HV_ACTIVE: U13.41 (PE10); also elsewhere on the board
HV_MISMATCH: U13.33 (PC4); also elsewhere on the board
NEG_AIR_CTRL: U13.56 (PD9); also elsewhere on the board
unnamed: C41.1, R47.1, X1.1
unnamed: C42.1, R48.1, X1.3
unnamed: J1.3, R57.2
unnamed: J2.3, R64.2
unnamed: R19.2, U16.1
unnamed: R52.1, U6.4
unnamed: R58.1, U16.4
unnamed: R59.2, U14.1
unnamed: R60.1, U14.4
unnamed: R61.2, U15.1
unnamed: R62.1, U15.4
unnamed: R46.1, SW1.2 (B)
unnamed: C39.2, U13.49 (VCAP_1)
unnamed: C40.2, U13.73 (VCAP_2)
POS_AIR_CTRL: U13.58 (PD11); also elsewhere on the board
PRE_AIR_CTRL: U13.54 (PB15); also elsewhere on the board
STATUS_1: U13.65 (PC8); also elsewhere on the board
STATUS_2: U13.32 (PA7); also elsewhere on the board
STATUS_3: U13.63 (PC6); also elsewhere on the board
STATUS_4: U13.31 (PA6); also elsewhere on the board
STATUS_5: U13.61 (PD14); also elsewhere on the board
STATUS_6: U13.30 (PA5); also elsewhere on the board

Notes on the sheet:
BOOT
CONNECTORS

Parts:
C32: 100n; C_0603_1608Metric
R39, R40: 4k7; R_0603_1608Metric
U10: AT24C521C; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C32.2, R39.1, R40.1, U10.8 (VCC); also elsewhere on the board
/I2C/SCL1: R40.2, U10.6 (SCL); also elsewhere on the board
/I2C/SDA1: R39.2, U10.5 (SDA); also elsewhere on the board
GND: C32.1, U10.1 (A0), U10.2 (A1), U10.3 (A2), U10.4 (GND), U10.7 (WP); also elsewhere on the board

Notes on the sheet:
EEPROM
